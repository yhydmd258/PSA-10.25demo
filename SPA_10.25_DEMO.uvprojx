# Keil uVision project SPA_10.25_DEMO.uvprojx, settings and files
target SPA_KEA128 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SPA_10.25demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Device\headers;.\Library\headers;.\User;.\User\BSP;.\User\LCD;.\User\CLK
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group CMSIS
    ./CMSIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group Startup
    ./Device/Startup/: startup_SKEAZ1284.s
  group Device
    ./Device/headers/: derivative.h SKEAZ1284.h system_SKEAZ1284.h
    ./Device/sources/: system_SKEAZ1284.c
  group Library
    ./Library/headers/: acmp.h adc.h bitband.h bme.h crc.h flash.h ftm.h gpio.h i2c.h ics.h kbi.h nvic.h pit.h pmc.h pwt.h rtc.h spi.h uart.h wdog.h
    ./Library/sources/: acmp.c adc.c crc.c flash.c ftm.c i2c.c ics.c kbi.c nvic.c pit.c pmc.c pwt.c rtc.c spi.c uart.c wdog.c
  group User
    ./User/: main.c project_cfg.h
    ./User/LCD/: LCD_ctrl.c LCD_data.c LCD_if.c
    ./User/BSP/: BSP_if.c
    ./User/CLK/: CLK.c
    ./User/Timer/: timer_if.c
    ./User/PIT/: pit_if.c
    ./User/LED/: LED_ctrl.c LED_data.c LED_I2C.c LED_if.c
    ./User/FTM/: FTM_ctrl.c FTM_if.c
    ./User/Deserialize/: deserialize_data.c deserialize_ctrl.c deserialize_if.c deserialize_uart.c
    ./User/CTP/: CTP_ctrl.c CTP_data.c CTP_if.c
    ./User/KBI/: KBI_if.c
